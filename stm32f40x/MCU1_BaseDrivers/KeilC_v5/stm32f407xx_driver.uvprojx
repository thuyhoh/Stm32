# Keil uVision project stm32f407xx_driver.uvprojx, settings and files
target Application (6220000::V6.22::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407xx_driver
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\CortexMx\Drivers\Inc;..\Drivers\stm32f407vg_drivers\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Src
    ./: main.c main.h
  group Inc
    ../../../CortexMx/Drivers/Inc/: CortexMx.h CortexMx_BitBand.h CortexMx_NVIC.h CortexMx_SysTick_Timer.h
    ../Drivers/stm32f407vg_drivers/Inc/: stm32f407xx.h stm32f407xx_dma_driver.h stm32f407xx_gpio_driver.h stm32f407xx_i2c_driver.h stm32f407xx_rcc_driver.h stm32f407xx_spi_driver.h stm32f407xx_uart_driver.h
    ./: stm32f407xx_can_driver.h
  group Drivers
    ../../../CortexMx/Drivers/Src/: CortexMx.c CortexMx_NVIC.c CortexMx_SysTick_Timer.c
    ../Drivers/stm32f407vg_drivers/Src/: stm32f407xx_dma_driver.c stm32f407xx_gpio_driver.c stm32f407xx_i2c_driver.c stm32f407xx_rcc_driver.c stm32f407xx_spi_driver.c stm32f407xx_uart_driver.c
    ./: stm32f407xx_can_driver.c
  group example
    ./Example/: 001_HSE_HSI_Configure.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
